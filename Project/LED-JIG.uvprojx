# Keil uVision project LED-JIG.uvprojx, settings and files
target LED-JIG (ARM-ADS)
  device: STM32F103VG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED-JIG +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\Libraries\inc;..\USER\include;..\uCOSIII\uC-CPU;..\uCOSIII\uC-LIB;..\uCOSIII\uCOS-III;..\uCOSIII\UCOS_BSP;..\uCOSIII\UCOS_CONFIG;..\uCOSIII\uCOS-III\Source;..\uCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\uCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\uCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\SYSTEM\delay;..\SYSTEM\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ../USER/source/: main.c stm32f10x_it.c KeyDriver.c System_Initialize.c LCD12864B.c STM32_UART.c MENU.c TaskApp.c IT8512B.c GP9034T.c AT24Cxx.c RTC.c LoraC8000.c LoraC6000.c RS485.c FlashOperate.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../Startup/: startup_stm32f10x_hd.s
  group Library
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group UCOSIII_BSP
    ../uCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../uCOSIII/uC-CPU/: cpu_core.c
    ../uCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../uCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../uCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../uCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../uCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s os_cpu.h
  group UCOSIII_CONFIG
    ../uCOSIII/UCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
software components: CMSIS:CORE 4.3.0
